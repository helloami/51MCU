# Keil uVision project lesson14.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: lesson14 +hex
  c flags: Optimize=8 SizeSpeed=1
  group SourceFiles
    ../source/: STARTUP.A51 DS18B20.c eeprom.c I2C.c keyboard.c Led.c main.c
  group IncludeFiles
    ../source/: config.h DS18B20.h eeprom.h I2C.h keyboard.h Led.h main.h
